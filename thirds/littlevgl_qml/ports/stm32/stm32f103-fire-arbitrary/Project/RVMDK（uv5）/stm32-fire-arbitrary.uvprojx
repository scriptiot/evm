# Keil uVision project stm32-fire-arbitrary.uvprojx, settings and files
target navi (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: firmware +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,LV_CONF_INCLUDE_SIMPLE
  c misc: --gnu
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\STM32_USB-FS-Device_Driver\inc;..\..\Mass_Storage\inc;..\..\EVM;..\..\..\..\..\..\littlevgl_qml;..\..\..\..\..\lvgl;..\..\..\..\..\..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_USB-FS-Device_Driver
    ../../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Mass_Storage
    ../../Mass_Storage/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/delay/: delay.c
  group BSP
    ../../User/Common/: Common.c
    ../../User/RTC/: rtc.c
    ../../User/LCD/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../../User/sram/: sram.c
    ../../User/font/: fonts.c
    ../../User/sdio/: bsp_sdio_sdcard.c
    ../../User/usart/: bsp_usart.c
    ../../User/Key/: bsp_key.c
    ../../User/led/: bsp_led.c
  group EVM
    ../../EVM/: lvgl_main.c
    ../../../../../liblvgl_qml/: qml_lvgl_module.c qml_lvgl_utils.c
    ../../../../../../../lib/arm-windows-armcc/: libqml.lib
  group lv_core
    ../../../../../lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lv_draw
    ../../../../../lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group lv_hal
    ../../../../../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../../../../../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
  group lv_objx
    ../../../../../lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lv_themes
    ../../../../../lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_font
    ../../../../../lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
  group fatfs
    ../../User/FATFS/: ff.c ffunicode.c diskio.c
